# IAR project scuba.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: $PROJ_DIR$; ..\..\3rdParty\EvalBoards\Renesas\YRDKRX62N\RPDL; ..\..\3rdParty\EvalBoards\Renesas\YRDKRX62N\LCD; ..\..\3rdParty\EvalBoards\Renesas\YRDKRX62N\BSP; ..\..\3rdParty\EvalBoards\Renesas\YRDKRX62N\BSP\uCOS-III; ..\..\3rdParty\uC-CPU; ..\..\3rdParty\uC-CPU\RX62N\IAR; ..\..\3rdParty\uC-LIB; ..\..\3rdParty\uCOS-III; ..\..\3rdParty\uCOS-III\Source; ..\..\3rdParty\uCOS-III\Ports\Renesas\RX600\IAR
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: Exercise5.srec
  ILINK.IlinkOutputFile: a.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\..\3rdParty\EvalBoards\Renesas\YRDKRX62N\RPDL\rx62n_library.a; ..\..\3rdParty\EvalBoards\Renesas\YRDKRX62N\LCD\glyphlib.a; ..\..\3rdParty\uCOS-III\uCOS-III.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  group (top)
    ./: adc.c adc.h adcisr.s alarm.c alarm.h interrupts.c main.c os_app_hooks.c protectedlcd.c protectedlcd.h protectedled.c protectedled.h pushbutton.c pushbutton.h scuba.c scuba.h
  group 3rdParty/BSP
    ../../3rdParty/EvalBoards/Renesas/YRDKRX62N/BSP/: bsp.c bsp.h bsp_tick_a.s bsp_tick_c.c iorx62n.h
    ../../3rdParty/EvalBoards/Renesas/YRDKRX62N/BSP/uCOS-III/: bsp_os.c bsp_os.h
  group 3rdParty/LCD
    ../../3rdParty/EvalBoards/Renesas/YRDKRX62N/LCD/: lcd.c lcd.h
  group 3rdParty/uC-CPU
    ../../3rdParty/uC-CPU/RX62N/IAR/: cpu.h cpu_a.s
    ../../3rdParty/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group 3rdParty/uC-LIB
    ../../3rdParty/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group 3rdParty/uCOS-III
    ../../3rdParty/uCOS-III/Ports/Renesas/RX600/IAR/: os_cpu.h os_cpu_a.s os_cpu_c.c
